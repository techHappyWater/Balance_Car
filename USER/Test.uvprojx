# Keil uVision project Test.uvprojx, settings and files
target Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\LIB\inc;..\Hardware\delay;..\Hardware\iic;..\Hardware\MPU6050;..\Hardware\MPU6050_DMP;..\Hardware\sys;..\Hardware\usart1;..\Hardware\Lcd1602;..\Hardware\IO;..\Hardware\TIM;..\Hardware\PID;..\Hardware\Encoder;..\Hardware\usart_other;..\Hardware\OLED;..\Hardware\ADC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c all.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/iic/: iic.c
    ../Hardware/MPU6050/: mpu6050.c
    ../Hardware/MPU6050_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/sys/: sys.c
    ../Hardware/usart1/: usart1.c
    ../Hardware/Lcd1602/: LCD1602.c
    ../Hardware/TIM/: Timer.c
    ../Hardware/PID/: PID.c
    ../Hardware/Encoder/: Encoder.c
    ../Hardware/usart_other/: uasrt_other.c
    ../Hardware/OLED/: oled.c
    ../Hardware/ADC/: adc.c
